# Keil uVision project TIMER.uvprojx, settings and files
target TIMER (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: TIMER +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\KEY;..\HARDWARE\TIMER;..\HARDWARE\BEEP;..\HARDWARE\LCD;..\HARDWARE\TOOLS;..\HARDWARE\CLOCK_FUCTION;..\HARDWARE\DISPLAY;..\HARDWARE\EXTI;..\HARDWARE\WATCH_FUCTION;..\HARDWARE\SPI;..\HARDWARE\W25QXX;..\HARDWARE\SDIO;..\USMART;..\MALLOC;..\FATFS\src;..\FATFS\exfuns;..\TEXT
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/TOOLS/: TOOLS.c
    ../HARDWARE/CLOCK_FUCTION/: CLOCK_FUCTION.c
    ../HARDWARE/DISPLAY/: DISPLAY.c
    ../HARDWARE/EXTI/: exti.c
    ../HARDWARE/WATCH_FUCTION/: WATCH_FUCTION.C
    ../HARDWARE/W25QXX/: w25qxx.c
    ../HARDWARE/SDIO/: sdio_sdcard.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_exti.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_i2c.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_wwdg.c stm32f10x_spi.c
  group README
    ../: README.TXT
  group TEXT
    ../TEXT/: fontupd.c text.c
  group MALLOC
    ../MALLOC/: malloc.c
  group FATFS
    ../FATFS/exfuns/: exfuns.c mycc936.c fattester.c
    ../FATFS/src/: ff.c diskio.c
